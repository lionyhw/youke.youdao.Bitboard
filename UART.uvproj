# Keil uVision project UART.uvproj, settings and files
target Target 1 (MCS-51)
  device: CMS8S5880 Cmsemicon
  cpu: IRAM(0 - 0xFF) IROM(0-0x3FFF) XRAM(0x0000-0x01FF) CLOCK(24000000) MODDP2
  output: BitBoard +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51 UART.C
